# Keil uVision project ARHSModule_G431.uvprojx, settings and files
target ARHSModule_G431 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ARHSModule_G431 +hex
  AfterMake: D:\D\JLB_Often\STM32\STM32projects\Projects\ARHSModule_G431\MDK-ARM\Keil5_disp_size_bar_v0.4.exe
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP_HardWare;../Drivers/SYSTEM/delay;../Drivers/SYSTEM/sys;../Drivers/BSP_HardWare/icm45686/imu;../Drivers/BSP_HardWare/icm45686;../USER/Angle;../USER/Math_DSP;../Drivers/BSP_HardWare/BMM350
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP_HardWare
    ../Drivers/BSP_HardWare/icm45686/imu/: inv_imu_driver.c inv_imu_transport.c
    ../Drivers/BSP_HardWare/: icm45686_task.c bmm350_task.c
    ../Drivers/BSP_HardWare/BMM350/: bmm350.c bmm350_oor.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
  group Application/ARHS
    ../USER/Angle/: angle.c
    ../USER/Math_DSP/: filter.c HANA_math.c
software components: CMSIS:CORE 6.1.0
